Commit message: updated calibration

File: urdf/link5_2_calibration.urdf (robot description, URDF)
Before this commit: robot link5, 9 links, 8 joints
Links:
- link calibration_link5/base_link_inertia: geometry visual mesh filename=package://gentact_ros_tools/meshes/link5_2.stl scale=1 1 1
